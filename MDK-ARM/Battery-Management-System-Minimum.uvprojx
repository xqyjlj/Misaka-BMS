# Keil uVision project Battery-Management-System-Minimum.uvprojx, settings and files
target Battery-Management-System-Minimum (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Battery-Management-System-Minimum +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;                                               ../Drivers/STM32F1xx_HAL_Driver/Inc;                                               ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                               ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                               ../Drivers/CMSIS/Include;                                               ..\Middleware\RT-Thread;                                               ..\Middleware\RT-Thread\components\finsh;                                               ..\Middleware\RT-Thread\include;                                               ..\Middleware\RT-Thread\include\libc;                                               ..\Middleware\Misaka-AT24CXX;                                               ..\Middleware\Misaka-Device\Misaka-Device-Soft_I2C;                                               ..\Middleware\SFUD\sfud\inc;                                               ..\Board;                                               ..\Thread;                                               ..\Middleware\Misaka-RGB-Bling;                                               ..\Middleware\ButtonDrive;                                               ..\Middleware\Misaka-Beep;                                               ..\Middleware\littlefs;                                               ..\Middleware\EasyFlash\easyflash\inc;                                               ..\Middleware\Fal\inc;                                               ..\Middleware\Misaka-Filter;                                               ..\Middleware\Misaka-LTC6811;                                               ..\Middleware\Misaka-FSC-Station
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/Board
    ../Board/: board.c system.c communicate.c timx.c analog.c eeprom.c temperature.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Thread
    ../Thread/: adc_mux.c Bling.c Key.c Beep.c bat_temperature.c ltc6811_thread.c bat_voltage.c bat_current.c ltc6811_check.c self_status.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_ll_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middleware/RT-Thread
    ../Middleware/RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middleware/RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_gcc.S
    ../Middleware/RT-Thread/: rtconfig.h
  group Middleware/Finsh
    ../Middleware/RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group Middleware/Misaka-Device/Soft_I2C
    ../Middleware/Misaka-Device/Misaka-Device-Soft_I2C/: Misaka_Device_Soft_I2C.c Misaka_Device_Soft_I2C_Port.c
  group Middleware/Misaka/AT24CXX
    ../Middleware/Misaka-AT24CXX/: Misaka_AT24CXX.c Misaka_AT24CXX_Port.c
  group Middleware/SFUD
    ../Middleware/SFUD/sfud/src/: sfud.c sfud_port.c sfud_sfdp.c
  group Middleware/Misaka-RGB-Bling
    ../Middleware/Misaka-RGB-Bling/: Misaka_RGB_Bling.c Misaka_RGB_Bling_Port.c
  group Middleware/ButtonDrive
    ../Middleware/ButtonDrive/: button.c
  group Middleware/Misaka-Beep
    ../Middleware/Misaka-Beep/: Misaka_Beep.c Misaka_Beep_Port.c
  group Middleware/Misaka-LTC6811
    ../Middleware/Misaka-LTC6811/: Misaka_LTC6811.c Misaka_LTC6811_Base.c Misaka_LTC6811_NTC_Table.c Misaka_LTC6811_Port.c
  group Middleware/Misaka-Filter
    ../Middleware/Misaka-Filter/: Misaka_Filter_LPF.c
  group Middleware/littlefs
    ../Middleware/littlefs/: lfs.c lfs_util.c littlefs_port.c
  group Middleware/Fal
    ../Middleware/Fal/src/: fal.c fal_flash.c fal_flash_sfud_port.c fal_partition.c fal_rtt.c
  group Middleware/EasyFlash
    ../Middleware/EasyFlash/easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_fal_port.c ef_iap.c ef_log.c ef_utils.c ef_sfud_port.c
  group Middleware/Misaka-FSC-Station
    ../Middleware/Misaka-FSC-Station/: Misaka_FSC_Station.c Misaka_FSC_Station_Port.c
software components: CMSIS:CORE 5.5.0
