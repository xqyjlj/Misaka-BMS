# Keil uVision project misaka_bms.uvprojx, settings and files
target misaka_bms (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: misaka_bms +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB
  c include: ..\cubemx\Core\Inc;..\cubemx\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\cubemx\Drivers\STM32F1xx_HAL_Driver\Inc;..\cubemx\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\cubemx\Drivers\CMSIS\Include;..\middleware\rt-thread;..\middleware\rt-thread\include;..\middleware\rt-thread\include\libc;..\middleware\rt-thread\components\finsh;..\board;..\board\inc;..\middleware\misaka_cutil\list\inc;..\middleware\misaka_cutil\sort\inc;..\middleware\misaka_cutil\string\inc;..\middleware\misaka_cutil\util\inc;..\middleware\misaka_at24cxx\inc;..\middleware\misaka_device\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: app_main.c
  group core
    ../cubemx/Core/Src/: adc.c can.c dma.c gpio.c iwdg.c main.c spi.c stm32f1xx_it.c tim.c usart.c stm32f1xx_hal_msp.c
  group board
    ../board/: board.c system.c
  group drivers/cmsis
    ../cubemx/Core/Src/: system_stm32f1xx.c
  group drivers/hal
    ../cubemx/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group middleware/finsh
    ../middleware/rt-thread/components/finsh/: cmd.c msh.c shell.c
  group middleware/misaka_at24cxx
    ../middleware/misaka_at24cxx/src/: at24cxx_port.c at24cxx.c
  group middleware/misaka_cutil
    ../middleware/misaka_cutil/list/src/: listd.c listdc.c lists.c listsc.c
    ../middleware/misaka_cutil/sort/src/: sortbubble.c sortinsert.c sortselect.c
    ../middleware/misaka_cutil/string/src/: string.c
    ../middleware/misaka_cutil/util/src/: util.c
  group middleware/misaka_device
    ../middleware/misaka_device/soft_i2c/: soft_i2c.c soft_i2c_port.c
  group middleware/rt-thread
    ../middleware/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../middleware/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S context_gcc.S
  group startup
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 5.5.0
